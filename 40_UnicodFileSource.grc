options:
  parameters:
    author: jesse.d.harris42
    generate_options: qt_gui
    id: UnicodFileSource
    output_language: python
    title: UnicodFileSource
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jesse.d.harris42/Desktop/SGT_Harris/1_SDR/PY_Activites/my_text_file.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '40'
    srate: samp_rate
    style1: '0'
    type: float
    ymax: '100'
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
