options:
  parameters:
    generate_options: qt_gui
    id: TransRecePureSine
    output_language: python
    title: TransRecePureSine
  states: {}

blocks:
- name: amplitu
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: ifgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '32'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: sigfreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 10e3
    step: 1e3
    stop: 200e3
    value: 70e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitu
    freq: sigfreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 2.41e9
    gain0: '0'
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '32'
    freq0: 2.42e9
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-110'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
