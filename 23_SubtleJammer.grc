options:
  parameters:
    author: jesse.d.harris42
    generate_options: qt_gui
    id: SubtleJammer
    output_language: python
    title: SubtleJammer
  states: {}

blocks:
- name: center_freq_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e6
    step: 10e3
    stop: 110e6
    value: 104.3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: center_freq_slider
    gain0: '0'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_slider
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_const_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
