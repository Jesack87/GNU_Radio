options:
  parameters:
    author: jesse.d.harris42
    generate_options: qt_gui
    id: Spectrum_Analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq_slider
  id: variable_qtgui_range
  parameters:
    label: center_freq_slider
    orient: Qt.Horizontal
    start: 100e6
    step: 10e6
    stop: 2.6e9
    value: 107.9e6
  states: {}
- name: if_gain_slider
  id: variable_qtgui_range
  parameters:
    label: if_gain_slider
    orient: Qt.Horizontal
    start: 100e6
    step: '8'
    stop: 2.6e9
    value: 107.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 18e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '40'
    freq0: center_freq_slider
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_slider
    fftsize: '8192'
    rate: '20'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
